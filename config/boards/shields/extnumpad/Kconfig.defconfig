## config/boards/shields/extnumpad/Kconfig.defconfig
```kconfig
if SHIELD_EXTNUMPAD

config ZMK_KEYBOARD_NAME
    default "Craig Ext Numpad"

endif
```
